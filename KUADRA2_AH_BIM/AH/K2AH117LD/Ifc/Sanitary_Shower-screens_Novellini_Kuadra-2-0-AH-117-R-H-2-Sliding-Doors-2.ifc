Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Shower-screens_Novellini_Kuadra-2-0-AH-117-R-H-2-Sliding-Doors-2.ifc
Time: 2020-03-25T13:28:30
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, Kuadra 2.0 AH 117 R/H - 2 Sliding Doors + 2 Fixed Panels
ePset_BIMobjectScript - Door Panel Material: Clear; Door Frame Material: Silver_B; LOD: 300; Door Width: 0.00117
ePset_BIMobject_BO - ProductName (BO_prodinfo): Kuadra 2.0 AH 117 R/H - 2 Sliding Doors + 2 Fixed Panels; SKU (BO_prodsku): K2AH117D; ManufacturName (BO_Manufac): Novellini; ProductFamily (BO_prodfam): KUADRA 2.0; ProductGroup (BO_prodgroup): Shower Enclosure; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 1170; Height (BO_height): 2000; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/novellini/product/K2AH117D; ProductDataUrl (BO_prodaturl): bimobject.com/novellini/product/K2AH117D; ProductUrl (BO_producturl): https://www.novellini.com/content/com/int/en/collections/shower-enclosures/kuadra-2-0/kuadra-2-0-ah.html; InstallationInstructions (BO_montins): https://www.novellini.com/content/dam/novellini-archive/Pdf_Montaggio/box/kuadra20/60094kd2_kuadra2_ah/60094KD2%20KUADRA2%20AH.pdf; TechnicalDescription (BO_techcert): https://www.novellini.com/content/dam/novellini-archive/Pdf_Scheda/NOVELLINI/2019/int/KUADRA20AH-2019-INT.pdf; MaterialMain (BO_mainmat): Glass; MaterialSecondary (BO_secmat): Aluminium; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Shower screens; BimObjectCategoryCode (BO_bocat_code): sanitary-shower-screens; IfcClassification (BO_ifcclas): Object; UnspscCode (BO_unspsc): 30181507; Uniclass14Code (BO_uniclass_1_4_code): L72118; Uniclass14Description (BO_uniclass_1_4_desc): Bath screens, curtains; Uniclass20Code (BO_uniclass_2_0_code): PR-31-06; Uniclass20Description (BO_uniclass_2_0_desc): Bathing Fittings; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_76_07; Uniclass2015Description (BO_uniclass2015_desc): Bath panels; NBSReference (BO_nbs_ref): 31-06; NBSReferenceDescription (BO_nbs_desc): Bathing Fittings; OmniClassCode (BO_omniclass_code): 23-31 17 17; OmniClassDescription (BO_omniclass_name): Shower Enclosures; MasterFormat2014Code (BO_masterformat2014_code): 12 35 30.23; MasterFormat2014Description (BO_masterformat2014_name): Bathroom Casework; UniFormat2Code (BO_uniformat2_code): C1030; UniFormat2Description (BO_uniformat2_name): Fittings; RegionEurope (BO_europe): AT, BA, BE, BG, CH, CZ, DE, ES, FR, GB, GR, HR, HU, IT, LT, LU, ME, NL, NO, PL, RO, RU, SI, SK, UA
